inherit packagegroup

RDEPENDS_${PN} += "foo"
