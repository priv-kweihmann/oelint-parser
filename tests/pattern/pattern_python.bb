def abc():
    a = 1

    def nested():
        b = 2

    c = 2

def def():
    d = 2

VAR = "1"