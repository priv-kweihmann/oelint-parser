A = "1"
A .= "1"
A =. "1"
A := "1"
A += "1"
A =+ "1"
A:append = " 1"
A:prepend = "1 "
A:remove = "1"
A:class-native = "1"
A:class-target = "1"
A:class-nativesdk = "1"

B = "3"

C = "@{oe.utils.something(d)}"
