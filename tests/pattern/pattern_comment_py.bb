# Some comment
# with more than a single line
def some_python_code():
    result = ''
    return result

# Just a comment
# across multiple lines

do_example() {
    bbwarn "This is an example warning"
}
