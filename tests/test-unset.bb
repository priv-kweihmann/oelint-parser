A = "1"

A:append = " 2"

unset A

A += "3"
A += "4"

unset A[some-flag]

A:remove = "4"
