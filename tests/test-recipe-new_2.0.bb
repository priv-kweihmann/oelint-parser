B:append = "X2"

do_example() {
    bbwarn "This is an example warning"
}

Y = "${P}"
