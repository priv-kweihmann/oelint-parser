require test.inc

B = "1"
