inherit global-foo

B = "1"
