inherit recipe-foo foo
