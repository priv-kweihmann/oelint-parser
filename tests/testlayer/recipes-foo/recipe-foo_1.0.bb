inherit foo
inherit foreign-foo

B = "1"
