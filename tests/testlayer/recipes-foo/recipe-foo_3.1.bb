inherit class-12 class-22
