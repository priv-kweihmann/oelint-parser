inherit class-1 class-2
