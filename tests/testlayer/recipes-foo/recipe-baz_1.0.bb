inherit recipe-foo

B = "1"
