FOO_A = "1"

include conf/machine/include/test.inc
