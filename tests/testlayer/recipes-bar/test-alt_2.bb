require test_${PV}.bb
