def do-foo():
    pass

do-bar() {
    :
}

addtask do-bar
deltask do-bar
